# IAR project GD32H75E_EVAL.ewp, settings and files
configuration GD32H75E (ARM, debug)
  General.OGChipSelectEditMenu: GD32H75ExM GD GD32H75ExM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H75E; GD32H75E_ESC
  ICCARM.CCIncludePath2: ..\..\..\..\GD32H75E_Firmware_Library\CMSIS\GD\GD32H75E\Include; ..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_standard_peripheral\Include; ..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_esc_library\Include; ..\inc; ..\..\..\Utilities; ..\ethercat\Src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: esc_exti.c esc_timer.c gd32h75e_it.c gdesc.c main.c systick.c
  group CMSIS
    ../../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/: gd32h75e_err_report.c system_gd32h75e.c
  group Doc
    ../: readme.txt
  group ESC_Peripherals
    ../../../../GD32H75E_Firmware_Library/GD32H75E_esc_library/Source/: gd32h75e_esc_intc.c gd32h75e_esc_ospi.c gd32h75e_esc_phy.c gd32h75e_esc_pmu.c gd32h75e_esc_syscfg.c gd32h75e_esc_timer.c
  group EtherCAT_Stack
    ../ethercat/Src/: cia402appl.c coeappl.c ecatappl.c ecatcoe.c ecatslv.c mailbox.c objdef.c sdoserv.c
  group GD32H75E_EVAL
    ../../../Utilities/: gd32h75ey_eval.c
  group GD32H75E_Peripherals
    ../../../../GD32H75E_Firmware_Library/GD32H75E_standard_peripheral/Source/: gd32h75e_adc.c gd32h75e_can.c gd32h75e_cmp.c gd32h75e_crc.c gd32h75e_ctc.c gd32h75e_dac.c gd32h75e_dbg.c gd32h75e_dma.c gd32h75e_edout.c gd32h75e_efuse.c gd32h75e_exmc.c gd32h75e_exti.c gd32h75e_fac.c gd32h75e_fmc.c gd32h75e_fwdgt.c gd32h75e_gpio.c gd32h75e_hpdf.c gd32h75e_i2c.c gd32h75e_lpdts.c gd32h75e_mdma.c gd32h75e_misc.c gd32h75e_ospi.c gd32h75e_ospim.c gd32h75e_pmu.c gd32h75e_rameccmu.c gd32h75e_rcu.c gd32h75e_rtc.c gd32h75e_spi.c gd32h75e_syscfg.c gd32h75e_timer.c gd32h75e_tmu.c gd32h75e_trigsel.c gd32h75e_trng.c gd32h75e_usart.c gd32h75e_vref.c gd32h75e_wwdgt.c
  group Startup
    ../../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/IAR/: startup_gd32h75e.s
