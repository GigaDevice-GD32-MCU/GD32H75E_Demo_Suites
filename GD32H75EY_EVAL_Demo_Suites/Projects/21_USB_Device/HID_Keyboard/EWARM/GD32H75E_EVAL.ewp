# IAR project GD32H75E_EVAL.ewp, settings and files
configuration GD32H75E_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32H75ExM GD GD32H75ExM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H75E; USE_USB_FS; USE_USBHS0
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\GD32H75E_Firmware_Library\CMSIS\GD\GD32H75E\Include; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_standard_peripheral\Include; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\driver\Include; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\device\core\Include; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\device\class\hid\Include; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\ustd\common; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\ustd\class\hid; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cdc_acm.srec
  ILINK.IlinkOutputFile: GD32H75E_EVAL.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32H75E_USBHS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.FPU2: 6
  ICCARM.CCDefines: GD32H75E; USE_USB_HS; USE_USBHS0; USE_IRC48M
  group App
    ../src/: app.c gd32h75e_it.c gd32h75e_usb_hw.c hid_keyboard_itf.c system_gd32h75e.c
  group CMSIS
    ../../../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/: gd32h75e_err_report.c
  group Doc
    ../: readme.txt
  group GD32H75E_EVAL
    ../../../../Utilities/: gd32h75ey_eval.c
  group GD32H75E_Peripherals
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_standard_peripheral/Source/: gd32h75e_ctc.c gd32h75e_exti.c gd32h75e_gpio.c gd32h75e_misc.c gd32h75e_pmu.c gd32h75e_rcu.c gd32h75e_syscfg.c gd32h75e_timer.c gd32h75e_usart.c
  group Startup
    ../../../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/IAR/: startup_gd32h75e.s
  group USB_Class
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_usbhs_library/device/class/hid/Source/: standard_hid_core.c
  group USB_Device
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
