# IAR project GD32H75E_EVAL.ewp, settings and files
configuration GD32H75E_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32H75ExM GD GD32H75ExM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H75E; USE_USB_FS; USE_USBHS0; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\GD32H75E_Firmware_Library\CMSIS\GD\GD32H75E\Include; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_standard_peripheral\Include; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\driver\Include; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\host\core\Include; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\host\class\msc\Include; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\ustd\common; ..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\ustd\class\msc; ..\fat_fs\inc; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cdc_acm.srec
  ILINK.IlinkOutputFile: GD32H75E_EVAL.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32H75E_USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: GD32H75E; USE_USB_HS; USE_USBHS0; _DLIB_FILE_DESCRIPTOR
  group App
    ../src/: app.c gd32h75e_it.c gd32h75e_usb_hw.c system_gd32h75e.c usbh_usr.c
  group CMSIS
    ../../../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/: gd32h75e_err_report.c
  group Doc
    ../: readme.txt
  group FatFs
    ../fat_fs/src/: ff.c ffunicode.c
  group GD32H75E_EVAL
    ../../../../Utilities/: gd32h75ey_eval.c
  group GD32H75E_Peripherals
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_standard_peripheral/Source/: gd32h75e_ctc.c gd32h75e_exmc.c gd32h75e_exti.c gd32h75e_gpio.c gd32h75e_misc.c gd32h75e_pmu.c gd32h75e_rcu.c gd32h75e_syscfg.c gd32h75e_timer.c gd32h75e_usart.c
  group Startup
    ../../../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/IAR/: startup_gd32h75e.s
  group USB_Class
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_usbhs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
