# Keil uVision project GD32H75EY_EVAL.uvprojx, settings and files
target GD32H75EY(USB_FS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H75EYMJ6 GigaDevice
  pack: GigaDevice.GD32H75E_DFP.0.0.1
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: msc_host +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_USB_FS USE_USBHS0  GD32H75E
  c include: ..\..\..\..\..\GD32H75E_Firmware_Library\CMSIS;..\..\..\..\..\GD32H75E_Firmware_Library\CMSIS\GD\GD32H75E\Include;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_standard_peripheral\Include;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\driver\Include;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\host\core\Include;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\host\class\hid\Include;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\ustd\common;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\ustd\class\hid;..\..\..\..\Utilities;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application
    ../src/: app.c gd32h75e_it.c gd32h75e_usb_hw.c usbh_usr.c system_gd32h75e.c
  group CMSIS
    ../../../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/: gd32h75e_err_report.c
  group GD32H75E_Peripherals
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_standard_peripheral/Source/: gd32h75e_ctc.c gd32h75e_exmc.c gd32h75e_exti.c gd32h75e_gpio.c gd32h75e_misc.c gd32h75e_pmu.c gd32h75e_rcu.c gd32h75e_syscfg.c gd32h75e_timer.c gd32h75e_usart.c
  group GD32H75E_EVAL
    ../../../../Utilities/: gd32h75ey_eval.c
  group Startup
    ../../../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/ARM/: startup_gd32h75e.s
  group USB_Driver
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../GD32H75E_Firmware_Library/GD32H75E_usbhs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group Doc
    ../: readme.txt
target GD32H75EY(USB_HS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H75EYMJ6 GigaDevice
  pack: GigaDevice.GD32H75E_DFP.0.0.1
  cpu: as above
  output: msc_host +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_USB_HS USE_USBHS0  GD32H75E
  c include: ..\inc;..\..\..\..\..\GD32H75E_Firmware_Library\CMSIS;..\..\..\..\..\GD32H75E_Firmware_Library\CMSIS\GD\GD32H75E\Include;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_standard_peripheral\Include;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\driver\Include;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\host\core\Include;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\host\class\hid\Include;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\ustd\common;..\..\..\..\..\GD32H75E_Firmware_Library\GD32H75E_usbhs_library\ustd\class\hid;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 5.6.0
